# Keil uVision project a.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: a +hex
  c flags: Optim=1
  c include: .\CMSIS_Driver-Core\library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./CMSIS_Driver-Core/startup/arm/: startup_LPC17xx.s
  group core & sys
    ./CMSIS_Driver-Core/core & system/: core_cm3.c system_LPC17xx.c
  group library
    ./CMSIS_Driver-Core/library/: lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_gpio.c lpc17xx_timer.c lpc17xx_adc.c
  group main
    ./: source.c
